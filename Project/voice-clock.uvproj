# Keil uVision project voice-clock.uvproj, settings and files
target STC89xx (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: voice-clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\System;..\UserCode
  group UserCode
    ../UserCode/: button.c delay.c gpio.c dht11.c lcd1602.c wt588.c ds1302.c mode.c timer.c
  group System
    ../System/: main.c task.c
